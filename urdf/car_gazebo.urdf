Commit message: 完成了相机组件

File: urdf/car_gazebo.urdf (robot description, URDF)
Before this commit: robot car, 3 links, 2 joints
Joints:
- joint base_USBcamera_joint: limit lower=-1.8 upper=1.8 effort=10.0 velocity=10 -> lower=-1.8 upper=1.8 effort=2.0 velocity=0.5
